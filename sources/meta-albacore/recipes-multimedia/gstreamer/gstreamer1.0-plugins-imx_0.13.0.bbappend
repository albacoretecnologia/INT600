PACKAGECONFIG_remove ?= "v4l2src v4l2sink vpu"
