PACKAGECONFIG_remove = "gles2 egl opencv"
