IMAGE_INSTALL_remove = "imx-gpu-viv-demos imx-gpu-viv-tools"
