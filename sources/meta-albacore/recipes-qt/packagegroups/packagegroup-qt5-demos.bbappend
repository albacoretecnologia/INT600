RDEPENDS_${PN}_append = " \
	qtserialport \
	cinematicexperience \
	qt5everywheredemo \
	qt5-opengles2-test \
	qtsmarthome \
	quitbattery \
	qt5-demo-extrafiles \
	"
