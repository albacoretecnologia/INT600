RDEPENDS_${PN} += " \
	qtbase \
	qtbase-plugins \
	qtbase-tools \
	qtbase-examples \
	${QT5_RDEPENDS_common} \
	"
